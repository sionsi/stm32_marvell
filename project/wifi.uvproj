# Keil uVision project wifi.uvproj, settings and files
target mcu_wifi (ARM-ADS)
  device: STM32F103RG STMicroelectronics
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32WIFI +hex
  c flags: Optim=3 wLevel=2
  c define: CHIP_F103,_FW_OUTSIDE,WIFI_CHIP=8801
  c include: ..\drivers\stm32f10x\inc;..\bsp\stm32f1xx\CMSIS;..\bsp\stm32f1xx\FWlib\inc;..\net\lwip\src\include\ipv4;..\net\lwip\src\include;..\net\lwip\src\arch;..\net\lwip\src;..\kernel\ucos\include;..\kernel\api\inc;..\app\inc;..\config;..\jpeg\jpeg-9a;..\net\udhcp-0.9.8;..\libmad-0.15.1b;..\net\libertas\inc;..\net\wpa;..\net\wlan_src\mlan;..\net\wlan_src\mlinux;..\net\wlan_src\user;..\net\wlan_src\mapp;..\net\wlan_src\mapp\wifidirectutl;..\dht11;..\oled
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --remove
  group bsp
    ../bsp/stm32f1xx/FWlib/src/: stm32f10x_adc.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c misc.c stm32f10x_pwr.c
    ../bsp/stm32f1xx/CMSIS/startup/: startup_stm32f10x_hd.s
    ../bsp/stm32f1xx/CMSIS/: core_cm3.c system_stm32f10x.c
  group drivers
    ../drivers/stm32f10x/src/: sdcard.c usart.c driver_misc.c w25p80.c
  group os
    ../kernel/ucos/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
    ../kernel/ucos/uCOS-II/Ports/ARM-Cortex-M3/IAR/: os_cpu_c.c os_cpu_a.asm
  group os_api
    ../kernel/api/src/: atomic.c mbox.c msg_q.c mutex.c sem.c task.c timer.c wait.c memory.c
  group lwip_api
    ../net/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip_arch
    ../net/lwip/src/arch/: sys_arch.c
  group lwip_core
    ../net/lwip/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../net/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group lwip_netif
    ../net/lwip/src/netif/: ethernetif.c etharp.c
  group udhcp
    ../net/udhcp-0.9.8/: dhcpd.c leases.c options.c packet.c serverpacket.c
  group mlinux
    ../net/wlan_src/mlinux/: moal_main.c moal_cfg80211.c moal_debug.c moal_ioctl.c moal_proc.c moal_sdio_mmc.c moal_shim.c moal_sta_cfg80211.c moal_uap_cfg80211.c moal_uap.c moal_uap_priv.c
  group mlan
    ../net/wlan_src/mlan/: mlan_11d.c mlan_11h.c mlan_11n.c mlan_11n_aggr.c mlan_11n_rxreorder.c mlan_cfp.c mlan_cmdevt.c mlan_init.c mlan_join.c mlan_meas.c mlan_misc.c mlan_scan.c mlan_sdio.c mlan_shim.c mlan_sta_cmd.c mlan_sta_cmdresp.c mlan_sta_event.c mlan_sta_ioctl.c mlan_sta_rx.c mlan_sta_tx.c mlan_txrx.c mlan_uap_cmdevent.c mlan_uap_ioctl.c mlan_uap_txrx.c mlan_wmm.c
  group muser
    ../app/src/: sys_misc.c wifi.c
    ../net/wlan_src/user/: skbuff.c usr_cfg.c
  group app
    ../app/src/: test_wifi.c main.c test_tcpip.c tcpapp.c webserver.c
  group monitor
    ../app/src/: debug.c
    ../monitor/: monitor.c
  group dht11
    ../dht11/: delay.c DHT11_BUS.c
  group oled
    ../oled/: oled.c
  group web
    ../web/: web.c
